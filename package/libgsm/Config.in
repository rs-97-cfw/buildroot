## package/libgsm/Config.in
```kconfig
config BR2_PACKAGE_LIBGSM
	bool "libgsm"
	help
	  Shared libraries for GSM 06.10 lossy speech compression.

	  http://www.quut.com/gsm
```
